# Keil uVision project osKernel.uvprojx, settings and files
target STM32L152RE (6140000::V6.14::ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: osKernel
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group APP
    ./: main.c osKernel.h osKernel.s osKernel.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
